Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-10-13T07:37:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170419_0315(x64) - Exporter 17.0.1128.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 13 07:37:32 2020 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{FC59966F-EED7-4AAF-BC6A-C1FD5B8676AA}\ifc * Database version: 5507 * Database creation date: Tue Oct 13 07:37:31 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 13 07:37:31 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 13 07:37:32 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 29744030_D_11164080_CVA7440_GRGR, 11164080_D_CVA7440_GRGR:29744030_D_11164080_CVA7440_GRGR:205094
In: Level 1
Type - Classification: CVA7000 (Uniformat); Material: z_Miele_Design_Glass, z_Miele_Design_CLST, z_Miele_Design_GRGR, z_Miele_Connection_Electric, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - Reference: 29744030_D_11164080_CVA7440_GRGR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
